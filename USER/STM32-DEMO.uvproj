# Keil uVision project STM32-DEMO.uvproj, settings and files
target LED-DEMO (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: STM32-DEMO +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\CMSIS;..\USER;..\FWlib\inc;..\FWlib\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUPCODE
    ../CMSIS/startup/: startup_stm32f10x_md.s
  group USER
    ./: main.c stm32f10x_it.c led.c delay.c Motor.c uart.c clock.c drv_gpio.c drv_spi.c drv_RF24L01.c Sonic.c protocal.c CAN1.c RobotModuleDriver.c
  group FWlib
    ../FWlib/src/: stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_tim.c stm32f10x_dma.c stm32f10x_usart.c misc.c stm32f10x_spi.c stm32f10x_exti.c stm32f10x_can.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
